# Allegro board wa2.brd

Outline 300 x 150 mm; copper layers: TOP, CORE, BOTTOM. Coordinates in mm from the lower left corner of the outline.
Outline path: rectangle 0,0 300,150

## Placement (name value [footprint] x y rotation side)
NOREF  -  [unnamed]  38 26 0 top
NOREF#2  -  [unnamed]  42 19 0 top
NOREF#3  -  [unnamed]  34.5 23 0 top

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
unnamed
  round 2 hole 3 unplated: (0,0)

## Nets

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
Net_2: length 217.5
  TOP w1: 42,19 45.5,22.5
  TOP w2: 45.5,22.5 46.33,22.5 59.24,35.41 108.59,35.41 115,29 130,29 138,37
  BOTTOM w1: 50,19 42,19
  BOTTOM w2: 136,39 110.5,13.5 64.67,13.5 56.88,21.29 52.29,21.29 50,19
